# Keil uVision project Project.uvprojx, settings and files
target STM32F429I_DISCO (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429I_DISCO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F429xx,USE_STM32F429I_DISCO,
  c misc: --C99
  c include: ..\Drivers\STM32F429i_HAL_Driver\Inc;..\Drivers\BSP\STM32F429I-Discovery;..\Middlewares\STemWin\Config\inc;..\Middlewares\STemWin\Lib;..\Drivers\BSP\Components\Common;..\Drivers\BSP\Components\ili9341;..\Drivers\BSP\Components\stmpe811;..\Drivers\CMSIS\Inc;..\Utilities\Fonts;..\Inc
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: BASIC_HelloWorld.c main.c stm32f4xx_it.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/ili9341/: ili9341.c ili9341.h
    ../Drivers/BSP/Components/stmpe811/: stmpe811.c stmpe811.h
  group Drivers/BSP/STM32429I_DISCO
    ../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery.h stm32f429i_discovery_io.c stm32f429i_discovery_io.h stm32f429i_discovery_lcd.c stm32f429i_discovery_lcd.h stm32f429i_discovery_sdram.c stm32f429i_discovery_sdram.h stm32f429i_discovery_ts.c stm32f429i_discovery_ts.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/: system_stm32f4xx.c
  group Middlewares/STemWin/Config
    ../Middlewares/STemWin/Config/: GUIConf.c LCDConf_stm32f429i_disco.c GUI_X.c
  group Middlewares/STemWin/Lib
    ../Middlewares/STemWin/Lib/: STemWin524b_CM4_Keil.lib
  group Drivers/STM32F429i_HAL_Driver
    ../Drivers/STM32F429i_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_hal_tim_ex.c
